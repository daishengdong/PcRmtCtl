# Keil uVision project JoyStickMouse.uvproj, settings and files
target HT_JBK_PC (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: StmPC +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application files
    ../source/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group USBLib
    ../source/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group FWLib
    ../Flib/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c misc.c
  group RVMDK
    ./: stm32f10x_vector.s
  group Doc
    ../: readme.txt
  group Driver
    ../driver/: 24l01.c tty.c Delay.c usart.c
